# Keil uVision project VirtualCOMPort.uvproj, settings and files
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL +hex
  AfterMake: fromelf.exe --bin -o ./COM_0x800A000.bin ./STM3210B-EVAL/STM3210B-EVAL.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
    ../src/: hw_config.c main.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c stm32_it.c debug.c timer.c trans_buffers.c miner.c delay.c
  group CMSIS
    ../src/: system_stm32l1xx.c system_stm32f10x.c system_stm32f37x.c system_stm32f30x.c
    ../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
    ../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s startup_stm32l1xx_mdp.s
    ../../../Libraries/CMSIS/Device/ST/STM32F37x/Source/Templates/arm/: startup_stm32f37x.s
    ../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_sdio.c stm32f10x_tim.c
  group STM3210B-EVAL
    ../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval.c
  group STM3210E-EVAL
    ../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval.c
  group Doc
    ../: readme.txt
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: STM3210E-EVAL +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target STM3210E-EVAL_XL (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL_XL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
